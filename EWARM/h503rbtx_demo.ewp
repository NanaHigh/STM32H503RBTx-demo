# IAR project h503rbtx_demo.ewp, settings and files
configuration h503rbtx_demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32H503RB ST STM32H503RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H503xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32H5xx_HAL_Driver/Inc; ../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: h503rbtx_demo.hex
  ILINK.IlinkOutputFile: h503rbtx_demo.out
  ILINK.IlinkIcfFile: stm32h503xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h503xx.s
  group Application/User/Core
    ../Core/Src/: gpio.c i2c.c icache.c icm42688.c m24m02.c main.c memorymap.c spi.c stm32h5xx_hal_msp.c stm32h5xx_it.c usart.c w25qxx.c write.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
